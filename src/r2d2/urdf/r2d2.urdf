Commit message: Fixing head radius

File: src/r2d2/urdf/r2d2.urdf (robot description, URDF)
Before this commit: robot r2d2, 7 links, 6 joints
Links:
- link head: geometry collision sphere radius=.4; visual sphere radius=.2
